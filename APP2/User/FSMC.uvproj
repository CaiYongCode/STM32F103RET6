# Keil uVision project FSMC.uvproj, settings and files
target STM32_F10X_PROJ (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FSMC +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\FSMC.bin ..\OBJ\FSMC.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3;..\User;..\HARDWARE\SD_Card;..\HARDWARE\Touch;..\HARDWARE;..\Initialize;..\uCGUI\AntiAlias;..\uCGUI\Config;..\uCGUI\ConvertColor;..\uCGUI\ConvertMono;..\uCGUI\Core;..\uCGUI\Font;..\uCGUI\GUI_X;..\uCGUI\LCDDriver;..\uCGUI\MultiLayer;..\uCGUI\Widget;..\uCGUI\WM;..\fatfs;..\uCGUI\MemDev;..\My_UI;..\UCOS-II\PORTS;..\UCOS-II\SOURCE;..\UCOS-II\CONFIG;..\HARDWARE\AUDIOSEL;..\HARDWARE\VS10XX;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x801f000 size 0x1a000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c iFlash.c
  group APP
    ../APP/: APP.c globaldata.c MessageProc.c globalfunc.c TimerTask.c PowerManager.c ExtModule.c TCP_Reconnect.c Lamp.c Update.c
  group STM32_Init
    ../Initialize/: Initialize.c
  group STM32F10x_LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_i2c.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group uC/OS-II/PORTS
    ../UCOS-II/PORTS/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uC/OS-II/SOURCE
    ../UCOS-II/SOURCE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC/OS-II/CONFIG
    ../UCOS-II/CONFIG/: includes.h os_cfg.h
  group Hardware
    ../Hardware/: IOctl.c dacai_touch.c PLC.c GPRS.c Key.c wdg.c RN8302.c LM75A.c DS1302.c
